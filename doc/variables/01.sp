# Exemplo vetor com let

.control
let myvector = [1, 2, 3, 4, 5]
.endc
