Testando sufixos

.control
set sufixos = (1T 1G 1Meg 1K 1mil 1m 1u 1n 1p 1f )
foreach bb $sufixos
    echo bb is $bb
end
.endc
